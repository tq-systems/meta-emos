SRC_URI = "git://github.com/google/protobuf.git;tag=b04e5cba356212e4e8c66c61bbe0c3a20537c5b9"
unset SRCREV
