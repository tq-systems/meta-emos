DEPENDS_class-native += " gettext-native"