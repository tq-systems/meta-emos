DESCRIPTION = "Teridian metering processor querying daemon - default firmware"

require teridiand-fw.inc
