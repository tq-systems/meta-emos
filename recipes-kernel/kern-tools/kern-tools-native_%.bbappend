# https://git.yoctoproject.org/yocto-kernel-tools/commit/?id=f589e1df23251d8319063da0a61c1016b2a0bf85
# Update symbol_why.py script for do_kernel_configcheck to support transitional attribute
SRCREV = "f589e1df23251d8319063da0a61c1016b2a0bf85"
