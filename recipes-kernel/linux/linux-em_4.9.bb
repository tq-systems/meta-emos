include linux-em.inc

PV = "4.9+git${SRCPV}"

# branch 'em-4.9.x+fslc' supports em300 and em310
SRCBRANCH = "em-4.9.x+fslc"
SRCREV = "d7da55d27b58921b62ea291dc7952ef2514f3485"
