include linux-em.inc

PV = "4.14+git${SRCPV}"

SRCBRANCH = "em-4.14.x"
SRCREV = "d67ac146e899ffa262fc46608d116f54179aa312"
