include linux-em.inc

PV = "4.19+git${SRCPV}"

SRCBRANCH = "em-4.19.x"
SRCREV = "e76ba8adf0baa91d3e1151d0e29e846d56a0bc0c"
