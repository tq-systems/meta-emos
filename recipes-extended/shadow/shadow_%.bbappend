EXTRA_OECONF:remove = " --with-group-name-max-length=24"
EXTRA_OECONF:append = " --with-group-name-max-length=40"
