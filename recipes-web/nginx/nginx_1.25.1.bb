require nginx.inc

# 1.24.x branch is the current stable branch, the recommended default
# 1.25.x is the current mainline branches containing all new features
DEFAULT_PREFERENCE = "-1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=79ad2eb837299421c4435dedc8897b3d"

SRC_URI[md5sum] = "699dea60ab7aea244da2d874c7066fe6"
SRC_URI[sha256sum] = "f09071ac46e0ea3adc0008ef0baca229fc6b4be4533baef9bbbfba7de29a8602"
