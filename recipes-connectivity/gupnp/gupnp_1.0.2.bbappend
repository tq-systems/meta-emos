FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append_emos = " \
	file://0001-context-manager-Fix-issue-when-using-linux-cm.patch \
"
