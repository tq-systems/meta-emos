LICENSE = "EDL-1.0"

LIC_FILES_CHKSUM = " \
    file://edl-v10;md5=3adfcc70f5aeb7a44f3f9b495aa1fbf3 \
    file://notice.html;md5=943f861069889acecebf51dfa24478e2 \
    file://about.html;md5=e5662cbb5f8fd5c9faac526e4077898e \
"
