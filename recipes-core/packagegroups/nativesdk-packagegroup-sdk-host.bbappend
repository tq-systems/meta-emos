RDEPENDS:${PN}:remove:emos = "\
	nativesdk-qemu \
	nativesdk-qemu-helper \
"
